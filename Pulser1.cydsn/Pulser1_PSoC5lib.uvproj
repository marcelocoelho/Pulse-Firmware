# Keil uVision project Pulser1_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Pulser1_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h VDAC_PulseRef.c VDAC_PulseRef.h VDAC_PulseRef_PM.c ADC_PulseIn.c ADC_PulseIn.h ADC_PulseIn_PM.c ADC_PulseIn_INT.c CapSense_1.c CapSense_1.h CapSense_1_CSHL.c CapSense_1_CSHL.h CapSense_1_INT.c CapSense_1_Pins.c CapSense_1_Pins.h CapSense_1_PM.c CapSense_1_SMS_Wrapper.c CapSense_1_TunerHelper.c CapSense_1_TunerHelper.h UART_Net.c UART_Net.h UART_Net_PM.c UART_Net_INT.c Pin_ProxIR_1_aliases.h Pin_ProxIR_2_aliases.h Pin_ProxIR_3_aliases.h AMux_ProxIR.c AMux_ProxIR.h ADC_SAR_ProxIR.c ADC_SAR_ProxIR.h ADC_SAR_ProxIR_INT.c ADC_SAR_ProxIR_PM.c TIA_PulseIn.c TIA_PulseIn.h TIA_PulseIn_PM.c Pin_PulseIn_minus_aliases.h Pin_PulseRef_aliases.h Pin_PulseIR_Intensity_aliases.h Pin_PulseRed_Intensity_aliases.h Opamp_PulseRef.c Opamp_PulseRef.h Opamp_PulseRef_PM.c Pin_PulseIn_plus_aliases.h Clock_PWM_PulseLEDs.c Clock_PWM_PulseLEDs.h Pin_PulseIR_on_aliases.h Pin_PulseIR_on.c Pin_PulseIR_on.h Pin_PulseRed_on_aliases.h Pin_PulseRed_on.c Pin_PulseRed_on.h PWM_PulseLEDs.c PWM_PulseLEDs.h PWM_PulseLEDs_PM.c ADC_PulseIn_Ext_CP_Clk.c ADC_PulseIn_Ext_CP_Clk.h ADC_PulseIn_theACLK.c ADC_PulseIn_theACLK.h ADC_PulseIn_AMux.c ADC_PulseIn_AMux.h CapSense_1_CompCH0.c CapSense_1_CompCH0.h CapSense_1_CompCH0_PM.c CapSense_1_AMuxCH0.c CapSense_1_AMuxCH0.h CapSense_1_IntClock.c CapSense_1_IntClock.h ADC_SAR_ProxIR_theACLK.c ADC_SAR_ProxIR_theACLK.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h IDAC8_PulseIR.c IDAC8_PulseIR.h IDAC8_PulseIR_PM.c IDAC8_PulseRed.c IDAC8_PulseRed.h IDAC8_PulseRed_PM.c isr_PulseReadAmbient.c isr_PulseReadAmbient.h isr_PulseReadIR.c isr_PulseReadIR.h Filter_PulseInBand.c Filter_PulseInBand.h Filter_PulseInBand_PM.c Filter_PulseInBand_PVT.c Filter_PulseInBand_PVT.h Filter_PulseInBand_RAM_Data.c Filter_PulseInBand_Coefficients.c PrISM_PulseIndicator.c PrISM_PulseIndicator.h PrISM_PulseIndicator_PM.c Clock_1.c Clock_1.h ShiftReg_DelaySenseIR.c ShiftReg_DelaySenseIR.h ShiftReg_DelaySenseIR_PM.c Pin_DevId_0_aliases.h Pin_DevId_0.c Pin_DevId_0.h PrISM_PulseIndicator_1.c PrISM_PulseIndicator_1.h PrISM_PulseIndicator_1_PM.c PrISM_PulseIndicator_2.c PrISM_PulseIndicator_2.h PrISM_PulseIndicator_2_PM.c Status_Reg_DevID.c Status_Reg_DevID.h Pin_DevId_1_aliases.h Pin_DevId_1.c Pin_DevId_1.h Pin_DevId_2_aliases.h Pin_DevId_2.c Pin_DevId_2.h Pin_DevId_3_aliases.h Pin_DevId_3.c Pin_DevId_3.h Pin_DevId_4_aliases.h Pin_DevId_4.c Pin_DevId_4.h Pin_DevId_5_aliases.h Pin_DevId_5.c Pin_DevId_5.h Pin_DevId_6_aliases.h Pin_DevId_6.c Pin_DevId_6.h Pin_DevId_7_aliases.h Pin_DevId_7.c Pin_DevId_7.h UART_Debug.c UART_Debug.h UART_Debug_PM.c UART_Debug_INT.c USBUART_1.c USBUART_1.h USBUART_1_audio.c USBUART_1_audio.h USBUART_1_boot.c USBUART_1_cdc.c USBUART_1_cdc.h USBUART_1_cls.c USBUART_1_descr.c USBUART_1_drv.c USBUART_1_episr.c USBUART_1_hid.c USBUART_1_hid.h USBUART_1_pm.c USBUART_1_std.c USBUART_1_vnd.c USBUART_1_cdc.inf USBUART_1_midi.c USBUART_1_midi.h USBUART_1_Dm_aliases.h Pin_BrightLEDCool_aliases.h Pin_BrightLEDCool.c Pin_BrightLEDCool.h Pin_BrightLEDWarm_aliases.h Pin_BrightLEDWarm.c Pin_BrightLEDWarm.h Pin_BrightLEDRed_aliases.h Pin_BrightLEDRed.c Pin_BrightLEDRed.h Pin_DebugButton_aliases.h Pin_DebugButton.c Pin_DebugButton.h Pin_DebugLED_aliases.h Pin_PylonType1_aliases.h Pin_PylonType1.c Pin_PylonType1.h Pin_PylonType0_aliases.h Pin_PylonType0.c Pin_PylonType0.h Pin_Rx_Net_Enable_aliases.h Pin_Rx_Net_Enable.c Pin_Rx_Net_Enable.h Pin_Tx_Net_Enable_aliases.h Pin_Tx_Net_Enable.c Pin_Tx_Net_Enable.h Pin_LightsOn_aliases.h Pin_LightsOn.c Pin_LightsOn.h CapSense_1_IdacCH0.c CapSense_1_IdacCH0.h CapSense_1_IdacCH0_PM.c USBUART_1_Dp_1_aliases.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: Pulser1_PSoC5lib (library)
