# Keil uVision project usbtest1_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: usbtest1_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h Current_Source_aliases.h Current_Source.c Current_Source.h Pin_Ground_aliases.h Pin_Ground.c Pin_Ground.h Mux0_0_aliases.h Mux0_0.c Mux0_0.h Mux0_1_aliases.h Mux0_1.c Mux0_1.h Mux0_2_aliases.h Mux0_2.c Mux0_2.h Mux0_3_aliases.h Mux0_3.c Mux0_3.h Mux1_0_aliases.h Mux1_0.c Mux1_0.h Mux1_1_aliases.h Mux1_1.c Mux1_1.h Mux1_2_aliases.h Mux1_2.c Mux1_2.h Mux1_3_aliases.h Mux1_3.c Mux1_3.h IDAC8.c IDAC8.h IDAC8_PM.c ADC_SAR_1.c ADC_SAR_1.h ADC_SAR_1_INT.c ADC_SAR_1_PM.c AMux_1.c AMux_1.h USBUART_1.c USBUART_1.h USBUART_1_audio.c USBUART_1_audio.h USBUART_1_boot.c USBUART_1_cdc.c USBUART_1_cdc.h USBUART_1_cls.c USBUART_1_descr.c USBUART_1_drv.c USBUART_1_episr.c USBUART_1_hid.c USBUART_1_hid.h USBUART_1_pm.c USBUART_1_std.c USBUART_1_vnd.c USBUART_1_cdc.inf USBUART_1_midi.c USBUART_1_midi.h ADC_SAR_0.c ADC_SAR_0.h ADC_SAR_0_INT.c ADC_SAR_0_PM.c AMux_0.c AMux_0.h ADC_SAR_1_IRQ.c ADC_SAR_1_IRQ.h ADC_SAR_1_theACLK.c ADC_SAR_1_theACLK.h USBUART_1_Dm_aliases.h USBUART_1_Dm.c USBUART_1_Dm.h USBUART_1_Dp_1_aliases.h USBUART_1_Dp_1.c USBUART_1_Dp_1.h ADC_SAR_0_IRQ.c ADC_SAR_0_IRQ.h ADC_SAR_0_theACLK.c ADC_SAR_0_theACLK.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: usbtest1_PSoC5lib (library)
