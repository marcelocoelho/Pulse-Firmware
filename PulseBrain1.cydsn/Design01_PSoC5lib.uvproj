# Keil uVision project Design01_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Design01_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h Pin_12_aliases.h Pin_12.c Pin_12.h PrISM_3.c PrISM_3.h PrISM_3_PM.c PrISM_6.c PrISM_6.h PrISM_6_PM.c Pin_10_aliases.h Pin_10.c Pin_10.h Pin_9_aliases.h Pin_9.c Pin_9.h PrISM_5.c PrISM_5.h PrISM_5_PM.c Pin_8_aliases.h Pin_8.c Pin_8.h Pin_7_aliases.h Pin_7.c Pin_7.h PrISM_4.c PrISM_4.h PrISM_4_PM.c Pin_6_aliases.h Pin_6.c Pin_6.h Pin_5_aliases.h Pin_5.c Pin_5.h Pin_11_aliases.h Pin_11.c Pin_11.h Pin_4_aliases.h Pin_4.c Pin_4.h Pin_3_aliases.h Pin_3.c Pin_3.h Clock_1.c Clock_1.h PrISM_2.c PrISM_2.h PrISM_2_PM.c USBUART_1.c USBUART_1.h USBUART_1_audio.c USBUART_1_audio.h USBUART_1_boot.c USBUART_1_cdc.c USBUART_1_cdc.h USBUART_1_cls.c USBUART_1_descr.c USBUART_1_drv.c USBUART_1_episr.c USBUART_1_hid.c USBUART_1_hid.h USBUART_1_pm.c USBUART_1_std.c USBUART_1_vnd.c USBUART_1_cdc.inf USBUART_1_midi.c USBUART_1_midi.h PrISM_1.c PrISM_1.h PrISM_1_PM.c Pin_2_aliases.h Pin_2.c Pin_2.h Pin_1_aliases.h Pin_1.c Pin_1.h USBUART_1_Dm_aliases.h USBUART_1_Dp_1_aliases.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Pin_13_aliases.h PrISM_7.c PrISM_7.h PrISM_7_PM.c Pin_14_aliases.h PrISM_8.c PrISM_8.h PrISM_8_PM.c Pin_15_aliases.h Pin_15.c Pin_15.h Pin_16_aliases.h Pin_16.c Pin_16.h PrISM_9.c PrISM_9.h PrISM_9_PM.c Pin_17_aliases.h Pin_17.c Pin_17.h Pin_18_aliases.h Pin_18.c Pin_18.h PrISM_10.c PrISM_10.h PrISM_10_PM.c Pin_19_aliases.h Pin_19.c Pin_19.h Pin_20_aliases.h Pin_20.c Pin_20.h PrISM_11.c PrISM_11.h PrISM_11_PM.c Pin_21_aliases.h Pin_21.c Pin_21.h Pin_22_aliases.h Pin_22.c Pin_22.h PrISM_12.c PrISM_12.h PrISM_12_PM.c Pin_23_aliases.h Pin_23.c Pin_23.h Pin_24_aliases.h Pin_24.c Pin_24.h UART_1.c UART_1.h UART_1_PM.c UART_1_INT.c PrISM_13.c PrISM_13.h PrISM_13_PM.c Pin_25_aliases.h Pin_25.c Pin_25.h Pin_26_aliases.h Pin_26.c Pin_26.h PrISM_14.c PrISM_14.h PrISM_14_PM.c Pin_27_aliases.h Pin_27.c Pin_27.h Pin_28_aliases.h Pin_28.c Pin_28.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: Design01_PSoC5lib (library)
