# Keil uVision project PulseBrain1_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: PulseBrain1_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h PrISM_3.c PrISM_3.h PrISM_3_PM.c PrISM_6.c PrISM_6.h PrISM_6_PM.c PrISM_5.c PrISM_5.h PrISM_5_PM.c PrISM_4.c PrISM_4.h PrISM_4_PM.c Clock_1.c Clock_1.h PrISM_2.c PrISM_2.h PrISM_2_PM.c PrISM_1.c PrISM_1.h PrISM_1_PM.c cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h PrISM_7.c PrISM_7.h PrISM_7_PM.c PrISM_8.c PrISM_8.h PrISM_8_PM.c PrISM_9.c PrISM_9.h PrISM_9_PM.c PrISM_10.c PrISM_10.h PrISM_10_PM.c PrISM_11.c PrISM_11.h PrISM_11_PM.c PrISM_12.c PrISM_12.h PrISM_12_PM.c PrISM_13.c PrISM_13.h PrISM_13_PM.c PrISM_14.c PrISM_14.h PrISM_14_PM.c Pin_Panel_LED_0_aliases.h Pin_Panel_LED_0.c Pin_Panel_LED_0.h Pin_Panel_LED_1_aliases.h Pin_Panel_LED_1.c Pin_Panel_LED_1.h Pin_Panel_LED_2_aliases.h Pin_Panel_LED_2.c Pin_Panel_LED_2.h Pin_Debug_Button_aliases.h Pin_Debug_Button.c Pin_Debug_Button.h Pin_PWM_Blue_3_aliases.h Pin_PWM_Blue_3.c Pin_PWM_Blue_3.h Pin_PWM_Warm_3_aliases.h Pin_PWM_Warm_3.c Pin_PWM_Warm_3.h Pin_PWM_Blue_2_aliases.h Pin_PWM_Blue_2.c Pin_PWM_Blue_2.h Pin_PWM_Cool_2_aliases.h Pin_PWM_Cool_2.c Pin_PWM_Cool_2.h Pin_PWM_Warm_2_aliases.h Pin_PWM_Warm_2.c Pin_PWM_Warm_2.h Pin_PWM_Blue_1_aliases.h Pin_PWM_Blue_1.c Pin_PWM_Blue_1.h Pin_PWM_Cool_1_aliases.h Pin_PWM_Cool_1.c Pin_PWM_Cool_1.h Pin_PWM_Cool_3_aliases.h Pin_PWM_Cool_3.c Pin_PWM_Cool_3.h Pin_PWM_Warm_1_aliases.h Pin_PWM_Warm_1.c Pin_PWM_Warm_1.h Pin_PWM_Blue_0_aliases.h Pin_PWM_Blue_0.c Pin_PWM_Blue_0.h Pin_PWM_Cool_0_aliases.h Pin_PWM_Cool_0.c Pin_PWM_Cool_0.h Pin_PWM_Warm_0_aliases.h Pin_PWM_Warm_0.c Pin_PWM_Warm_0.h Pin_PWM_Warm_4_aliases.h Pin_PWM_Cool_4_aliases.h Pin_PWM_Blue_4_aliases.h Pin_PWM_Blue_4.c Pin_PWM_Blue_4.h Pin_PWM_Warm_5_aliases.h Pin_PWM_Warm_5.c Pin_PWM_Warm_5.h Pin_PWM_Cool_5_aliases.h Pin_PWM_Cool_5.c Pin_PWM_Cool_5.h Pin_PWM_Blue_5_aliases.h Pin_PWM_Blue_5.c Pin_PWM_Blue_5.h Pin_PWM_Warm_6_aliases.h Pin_PWM_Warm_6.c Pin_PWM_Warm_6.h Pin_PWM_Cool_6_aliases.h Pin_PWM_Cool_6.c Pin_PWM_Cool_6.h Pin_PWM_Blue_6_aliases.h Pin_PWM_Blue_6.c Pin_PWM_Blue_6.h Pin_PWM_Warm_7_aliases.h Pin_PWM_Warm_7.c Pin_PWM_Warm_7.h Pin_PWM_Cool_7_aliases.h Pin_PWM_Cool_7.c Pin_PWM_Cool_7.h Pin_PWM_Blue_7_aliases.h Pin_PWM_Blue_7.c Pin_PWM_Blue_7.h Pin_PWM_Warm_8_aliases.h Pin_PWM_Warm_8.c Pin_PWM_Warm_8.h Pin_PWM_Cool_8_aliases.h Pin_PWM_Cool_8.c Pin_PWM_Cool_8.h Pin_PWM_Blue_8_aliases.h Pin_PWM_Blue_8.c Pin_PWM_Blue_8.h Pin_Debug_LED_aliases.h Pin_Debug_LED.c Pin_Debug_LED.h UART_Debug.c UART_Debug.h UART_Debug_PM.c UART_Debug_INT.c UART_Sensor.c UART_Sensor.h UART_Sensor_PM.c UART_Sensor_INT.c USBUART_Central.c USBUART_Central.h USBUART_Central_audio.c USBUART_Central_audio.h USBUART_Central_boot.c USBUART_Central_cdc.c USBUART_Central_cdc.h USBUART_Central_cls.c USBUART_Central_descr.c USBUART_Central_drv.c USBUART_Central_episr.c USBUART_Central_hid.c USBUART_Central_hid.h USBUART_Central_pm.c USBUART_Central_std.c USBUART_Central_vnd.c USBUART_Central_cdc.inf USBUART_Central_midi.c USBUART_Central_midi.h USBUART_Central_Dm_aliases.h USBUART_Central_Dp_1_aliases.h Pin_PWM_Warm_4.c Pin_PWM_Warm_4.h Pin_PWM_Cool_4.c Pin_PWM_Cool_4.h UART_Debug_BOOT.c UART_Sensor_BOOT.c USBUART_Central_Dm.c USBUART_Central_Dm.h USBUART_Central_Dp_1.c USBUART_Central_Dp_1.h UART_Debug_IntClock.c UART_Debug_IntClock.h UART_Sensor_IntClock.c UART_Sensor_IntClock.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: PulseBrain1_PSoC5lib (library)
