# Keil uVision project USB_UART01_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: USB_UART01_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h USBUART_1.c USBUART_1.h USBUART_1_audio.c USBUART_1_audio.h USBUART_1_boot.c USBUART_1_cdc.c USBUART_1_cdc.h USBUART_1_cls.c USBUART_1_descr.c USBUART_1_drv.c USBUART_1_episr.c USBUART_1_hid.c USBUART_1_hid.h USBUART_1_pm.c USBUART_1_std.c USBUART_1_vnd.c USBUART_1_cdc.inf USBUART_1_midi.c USBUART_1_midi.h LCD.c LCD.h LCD_PM.c USBUART_1_Dm_aliases.h USBUART_1_Dp_1_aliases.h LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: USB_UART01_PSoC5lib (library)
